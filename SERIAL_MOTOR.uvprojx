# Keil uVision project SERIAL_MOTOR.uvprojx, settings and files
target SERIAL_MOTOR (6070000::V6.7::.\ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: SERIAL_MOTOR
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7
  c define: DEVICE_PORTOUT=1 DEVICE_SERIAL_ASYNCH=1 DEVICE_I2C_ASYNCH=1 DEVICE_ANALOGIN=1 TARGET_FF_ARDUINO TOOLCHAIN_ARM_STD MBED_MINIMAL_PRINTF DEVICE_I2CSLAVE=1 __MBED__=1 USE_HAL_DRIVER DEVICE_USTICKER=1 DEVICE_WATCHDOG=1 DEVICE_PWMOUT=1 DEVICE_SPI_ASYNCH=1 TARGET_M4 __CMSIS_RTOS DEVICE_PORTINOUT=1 TARGET_STM32F4 DEVICE_FLASH=1 TARGET_NAME=NUCLEO_F446RE MULADDC_CANNOT_USE_R7 __MBED_CMSIS_RTOS_CM DEVICE_MPU=1 TARGET_RELEASE TRANSACTION_QUEUE_SIZE_SPI=2 DEVICE_RESET_REASON=1 MBED_ROM_START=0x8000000 MBED_RAM_SIZE=0x20000 STM32F446xx ARM_MATH_CM4 USE_FULL_LL_DRIVER DEVICE_PORTIN=1 MBED_RAM_START=0x20000000 DEVICE_CAN=1 __FPU_PRESENT=1 DEVICE_SERIAL=1 DEVICE_RTC=1 TOOLCHAIN_ARMC6 TARGET_NUCLEO_F446RE DEVICE_I2C=1 DEVICE_ANALOGOUT=1 DEVICE_SLEEP=1 DEVICE_STDIO_MESSAGES=1 __ASSERT_MSG TARGET_STM DEVICE_INTERRUPTIN=1 TARGET_CORTEX TOOLCHAIN_ARM TARGET_LIKE_CORTEX_M4 TARGET_CORTEX_M MBED_ROM_SIZE=0x80000 DEVICE_SERIAL_FC=1 DEVICE_SPI=1 MBED_BUILD_TIMESTAMP=1668817497.9274397 DEVICE_LPTICKER=1 MBED_TRAP_ERRORS_ENABLED=1 TARGET_STM32F446xE TARGET_RTOS_M4_M7 TARGET_MCU_STM32 TARGET_FF_MORPHO __CORTEX_M4 DEVICE_SPISLAVE=1 TARGET_LIKE_MBED
  c misc: -Wno-armcc-pragma-push-pop -mcpu=cortex-m4 -fno-rtti -fshort-enums -Wno-deprecated-register -Wno-reserved-user-defined-literal -fdata-sections -mfloat-abi=hard -mthumb -fno-c++-static-destructors -fno-exceptions -Wno-armcc-pragma-anon-unions -c -mfpu=fpv4-sp-d16 --target=arm-arm-none-eabi -fshort-wchar -include mbed_config.h
  c include: /usr/src/mbed-sdk;mbed;mbed/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device;mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__FPU_PRESENT=1,-DARM_MATH_CM4,-D__CORTEX_M4,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__MBED_CMSIS_RTOS_CM,-DSTM32F446xx,-D__CMSIS_RTOS,-DUSE_FULL_LL_DRIVER,-DUSE_HAL_DRIVER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_ARM_STD/stm32f446xx.sct
  link misc: --predefine="-DMBED_BOOT_STACK_SIZE=4096" --show_full_path --predefine="-DMBED_ROM_SIZE=0x80000" --predefine="-DMBED_RAM_SIZE=0x20000" --legacyalign --any_contingency --predefine="-DMBED_ROM_START=0x8000000" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_RAM_START=0x20000000" --inline --keep=os_cb_sections --cpu=Cortex-M4
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_F446RE/TOOLCHAIN_ARM_STD/: analogin_api.o analogin_device.o analogout_api.o analogout_device.o can_api.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_init_pre.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o startup_stm32f446xx.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal_can.o stm32f4xx_hal_cec.o stm32f4xx_hal_cortex.o stm32f4xx_hal_crc.o stm32f4xx_hal_cryp.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_mmc.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_adc.o stm32f4xx_ll_crc.o stm32f4xx_ll_dac.o stm32f4xx_ll_dma.o stm32f4xx_ll_dma2d.o stm32f4xx_ll_exti.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_gpio.o stm32f4xx_ll_i2c.o stm32f4xx_ll_lptim.o stm32f4xx_ll_pwr.o stm32f4xx_ll_rcc.o stm32f4xx_ll_rng.o stm32f4xx_ll_rtc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_spi.o stm32f4xx_ll_tim.o stm32f4xx_ll_usart.o stm32f4xx_ll_usb.o stm32f4xx_ll_utils.o stm_spi_api.o system_clock.o system_stm32f4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_F446RE/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/device/: cmsis.h cmsis_nvic.h flash_data.h hal_tick.h stm32f446xx.h stm32f4xx.h system_stm32f4xx.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/: objects.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/TARGET_STM32F446xE/TARGET_NUCLEO_F446RE/: PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_F446RE/TARGET_STM/TARGET_STM32F4/device/: stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
  group SERIAL_MOTOR
    ./: main.cpp mbed_config.h
